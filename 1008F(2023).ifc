Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-21T19:57:43
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20191106_1200(x64) - Exporter 20.2.1.1 - Alternate UI 20.2.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Oct 21 19:57:43 2023 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\00bcdd55-e729-4a74-9953-da3241b926e8\53f22ac3-5e40-4f74-b54e-8c1420733dc9\ifc * Database version: 5507 * Database creation date: Sat Oct 21 19:57:42 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Oct 21 19:57:42 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Oct 21 19:57:42 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 1008F Washbasin faucet, 1008F(2023):1008F Washbasin faucet:358928
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - FaucetNominalDepth: 160 mm; FaucetNominalHeight: 147 mm; FaucetNominalWidth: 50 mm; HandShowerNominalDepth: 64.3 mm; HandShowerNominalHeight: 296.7 mm; HandShowerNominalWidth: 49.3 mm; InletConnectionSize: 10 mm
Type - General - Author: BIMStone; BIMObjectName: 1008F(2023); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: Washbasin faucet with Bidetta hand shower.; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 01/06/2023
Type - Green Building Properties - Approval KIWA SE Type Approval: 1490; CO2 Emissions (A1-A3): 11.04; CO2 Emissions (A4): 0.31; CO2 Emissions (B7): 2410.2; CO2 Emissions (C2): 0.02; CO2 Emissions (C3): 0.02; CO2 Emissions (C4): 0.08; CO2 Emissions (D): -7.85; EAN Number: 6414150077739; EN Standard: EN 817, EN 1113; ETIM Class Number: EC011328 Washbasin mixing tap; LVI Number: 6110329; Noise Class: I (ISO 3822) Oras lab.; NRF Number: 4200171; RSK Number: 8277682; Sales Package dimensions (LxWxH): 585 x 225 x 95; Sintef Certificate: Sintef Nr. 3638; STF Certificate: EUFI29-22005194-TH; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/1008F; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL Environmental Product Declaration EPD: http://www.oras.com/fileadmin/resources/184523_EPD_Washbasin faucet.pdf; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL KIWA SE Type Approval: http://static.oras.com/KIWASETypeApproval/1008F; URL Materials Declaration: http://www.oras.com/fileadmin/resources/182844_1008F_materialsdeclaration.pdf; URL REACH: http://static.oras.com/doc/reach; URL SINTEF: http://static.oras.com/Sintef/1008F; URL STF: http://static.oras.com/STF/1008F; VVS Number: 703895604
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/1008F; 3D View: https://static.oras.com/AR/1008F; Catalog Drawing URL: http://static.oras.com/catdrw/1008F; Dimension Drawing URL: http://static.oras.com/dimdrw/1008F; FDV Document URL: http://www.oras.com/datasheet/1008F/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/1008F; Group: Washbasin faucet; Installation and Maintenance Guide URL: http://static.oras.com/manual/1008F; Interactive AR View URL: https://static.oras.com/AR/1008F; Long Marketing: Washbasin faucet with Bidetta hand shower. Fixed spout, aerator and pop-up waste. Shower hose 1.75 m, wall bracket. There are also in-built limitation options for water temperature and maximum flow-rate. F = with flexible pipes; Manufacturer: Oras; Market: International;Finland;Norway;Sweden;Denmark;Poland;Russia;Estonia;Lithuania;Latvia;Ukraine; Mobile Product Information URL: http://mpi.oras.com/1008F; Model: 1008F Washbasin faucet; Name_en: 1008F Washbasin faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 1008F; Product Family: Oras Safira; Product Image URL: http://static.oras.com/image/1008F; Product URL: http://static.oras.com/1008F; Spare-Part Information URL: http://static.oras.com/sp/1008F; Technical DataSheet URL: http://www.oras.com/datasheet/1008F/en; Type Name: 1008F Washbasin faucet; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: 3S-installation system for safe and simple mounting; Aerator: Standard aerator; Backflow Prevention EN1717: HC; Connection: Flexible inlet pipes; Connection Size: G3/8; Extensions: Pop-up waste with draw-rod; Flow Rate At 300kPa: 0.00459091 m3/s; Hand Shower: Bidetta hand shower; Installation Type: Deck mounted; Lever Handle: Single operating lever/handle;Hot/Cold symbols; Max. Hot Water Supply: 70 kg/K/s3; Mechanical Parts: ø 40 mm ceramic cartridge for flow and temperature control; Mounting Holes: 1 hole; Pressure Loss With Flow 01ls: 160000 Pa; Shower Parts: Hand shower;Shower holder;Shower hose (1750 mm); Spout Projection: 107 mm; Spout Type: Fixed spout; Surface treatment: Chrome; Temperature: Temperature limiter; Temperature Adjustments: Limitation option for maximum temperature and flow-rate; Working Pressure: 50 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 1008F(2023); Features: Single-lever;Bidetta; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 1008F; Name: 1008F Washbasin faucet; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet:50x160x162 mm / Hand shower: 46x65x287 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ValveTypeCommon - ValvePattern: n/a; ValveOperation: n/a; ValveMechanism: n/a; FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeFaucet - Finish: Polished
Pset_DistributionFlowElementCommon - Reference: 1008F Washbasin faucet; sets with these values: 2
Pset_ElementShading - Color: Chrome
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: 1008F; Manufacturer: Oras
Pset_ProductRequirements - Name: 1008F Washbasin faucet; Category: Plumbing Fixtures
Constraints - DistanceX-Axis: 100 mm; DistanceY-Axis: 100 mm; Elevation from Level: 0 mm; FaucetDefaultElevation: 900 mm; HandShowerDefaultElevation: 900 mm; Hand Shower Visibility: yes; Host: Level : Level 1; Level: Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.0768389 m2; Volume: 0.00212093 m3
Identity Data - Mark: 4
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 1008F(2023): 1008F Washbasin faucet; Family and Type: 1008F(2023): 1008F Washbasin faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 1008F(2023): 1008F Washbasin faucet; Type Id: 1008F(2023): 1008F Washbasin faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
